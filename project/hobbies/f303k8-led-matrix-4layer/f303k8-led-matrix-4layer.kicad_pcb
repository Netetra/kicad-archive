# Repository Netetra/kicad-archive

## KiCad design project/hobbies/f303k8-led-matrix-4layer/f303k8-led-matrix-4layer.kicad_pcb

Parts:
C1, C2, C3, C6, C7, C8: 0.1uF; C_0603_1608Metric
C4: 0.47uF; C_0603_1608Metric
C5: 4.7uF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
D2: Yellow; LED_0603_1608Metric
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: Red; LED_0603_1608Metric
H1: MountingHole; MountingHole_2.2mm_M2
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: Boot; PinHeader_1x02_P1.27mm_Vertical; not fitted
R1, R2: 5.1kΩ; R_0603_1608Metric
R3, R7: 10kΩ; R_0603_1608Metric
R4, R5, R6: 100Ω; R_0603_1608Metric
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1kΩ; R_0603_1608Metric
TP1, TP3: TX; TestPoint_Pad_D1.0mm
TP2, TP4: RX; TestPoint_Pad_D1.0mm
U1: USBLC6-2SC6; SOT-23-6
U2: CH552E; MSOP-10_3x3mm_P0.5mm
U3: CH213K; SOT-23-3
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U5: NJM12888; SOT-23-5

Connections:
+3.3V: C4.1, C5.1, C6.1, C7.1, C8.1, J2.2, R8.1, R9.1, TP3.1, U4.1 (VDD), U4.5 (VDDA), U4.17 (VDD), U5.5 (Vout)
COL_A: R10.1, U4.13 (PA7)
COL_B: R11.1, U4.12 (PA6)
COL_C: R12.1, U4.10 (PA4)
COL_D: R13.1, U4.7 (PA1)
COL_E: R14.1, U4.27 (PB4)
COL_F: R15.1, U4.28 (PB5)
COL_G: R16.1, U4.30 (PB7)
COL_H: R17.1, U4.29 (PB6)
D+: R7.2, U1.4 (I/O2), U2.6 (UDP)
D-: U1.6 (I/O1), U2.7 (UDM)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.1, R3.1, TP4.1, U1.2 (GND), U2.8 (GND), U3.1 (GND), U4.16 (VSS), U4.32 (VSS), U5.2 (GND)
NRST: R4.1, U4.4 (NRST)
unnamed: D1.2 (A), R8.2
unnamed: D2.2 (A), R9.2
unnamed: D10.2 (A), D18.2 (A), D26.2 (A), D34.2 (A), D42.2 (A), D50.2 (A), D58.2 (A), D66.2 (A), R17.2
unnamed: D3.2 (A), D11.2 (A), D19.2 (A), D27.2 (A), D35.2 (A), D43.2 (A), D51.2 (A), D59.2 (A), R10.2
unnamed: D4.2 (A), D12.2 (A), D20.2 (A), D28.2 (A), D36.2 (A), D44.2 (A), D52.2 (A), D60.2 (A), R11.2
unnamed: D5.2 (A), D13.2 (A), D21.2 (A), D29.2 (A), D37.2 (A), D45.2 (A), D53.2 (A), D61.2 (A), R12.2
unnamed: D6.2 (A), D14.2 (A), D22.2 (A), D30.2 (A), D38.2 (A), D46.2 (A), D54.2 (A), D62.2 (A), R13.2
unnamed: D7.2 (A), D15.2 (A), D23.2 (A), D31.2 (A), D39.2 (A), D47.2 (A), D55.2 (A), D63.2 (A), R14.2
unnamed: D8.2 (A), D16.2 (A), D24.2 (A), D32.2 (A), D40.2 (A), D48.2 (A), D56.2 (A), D64.2 (A), R15.2
unnamed: D9.2 (A), D17.2 (A), D25.2 (A), D33.2 (A), D41.2 (A), D49.2 (A), D57.2 (A), D65.2 (A), R16.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.2
unnamed: J1.A6 (D+), J1.B6 (D+), U1.3 (I/O2)
unnamed: J1.A7 (D-), J1.B7 (D-), U1.1 (I/O1)
unnamed: J2.1, R7.1
unnamed: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS), U3.3 (VI+)
unnamed: R4.2, U2.2 (P1.5)
unnamed: R5.2, U2.3 (P1.6)
unnamed: R6.2, U2.4 (P1.7)
unnamed: C2.1, U2.10 (V33)
unnamed: R3.2, U4.31 (BOOT0)
PRG_LED: D2.1 (K), U2.1 (P1.4)
ROW_A: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), U4.26 (PB3)
ROW_B: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U4.25 (PA15)
ROW_C: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), U4.22 (PA12)
ROW_D: D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), U4.21 (PA11)
ROW_E: D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), U4.20 (PA10)
ROW_F: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), U4.19 (PA9)
ROW_G: D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), U4.18 (PA8)
ROW_H: D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), U4.14 (PB0)
RX: TP2.1, U4.9 (PA3)
SWCLK: R6.1, U4.24 (PA14)
SWDIO: R5.1, U4.23 (PA13)
TX: TP1.1, U4.8 (PA2)
VBUS: C1.1, C3.1, U2.9 (VCC), U3.2 (VO-), U5.1 (Vin), U5.3 (Control)

Board: 4 copper layers, 35.0 x 25.0 mm, 103 parts (72 on the bottom side), 48 nets.

File project/hobbies/f303k8-led-matrix-4layer/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C6, C7, C8",0603,6,0.1uF,
C4,0603,1,0.47uF,
C5,0603,1,4.7uF,
D1,0603,1,Blue,
"D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D4, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D5, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D6, D60, D61, D62, D63, D64, D65, D66, D7, D8, D9",0603,64,Red,
D2,0603,1,Yellow,
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0_16P,
J2,PinHeader_1x02_P1.27mm_Vertical,1,Boot,
"R1, R2",0603,2,5.1kΩ,
"R10, R11, R12, R13, R14, R15, R16, R17, R8, R9",0603,10,1kΩ,
"R3, R7",0603,2,10kΩ,
"R4, R5, R6",0603,3,100Ω,
"TP1, TP3",TestPoint_Pad_D1.0mm,2,TX,
"TP2, TP4",TestPoint_Pad_D1.0mm,2,RX,
U1,SOT-23-6,1,USBLC6-2SC6,
U2,MSOP-10_3x3mm_P0.5mm,1,CH552E,
U3,SOT-23-3,1,CH213K,
U4,LQFP-32_7x7mm_P0.8mm,1,STM32F303K8Tx,
U5,SOT-23-5,1,NJM12888,

## KiCad design project/motor-driver/bldc-v1/bldc-v1.kicad_pcb

Parts:
C1, C4, C6: 1uF; C_0805_2012Metric
C2, C3, C5: 0.1uF; C_0603_1608Metric
C9: 100uF; CP_Radial_D8.0mm_P3.50mm
C10: 47uF; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3: 1N4148W; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Power; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Input; JST_XH_S7B-XH-A_1x07_P2.50mm_Horizontal
J3: Output; AMASS_MR30PW-FB_1x03_P3.50mm_Horizontal
Q1, Q2, Q3, Q4, Q5, Q6: NMOS; TO-252-2
R1, R3, R5, R6, R9, R10: 10Ω; R_0603_1608Metric
R2, R4, R7, R8, R11, R12, R13, R14, R15, R16, R17, R18: 10kΩ; R_0603_1608Metric
R19, R20, R21, R22, R23, R24: 1kΩ; R_0603_1608Metric
U1, U2, U3: IR2302; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C2.1, C3.1, C5.1, C9.1, C10.1, D1.2 (A), D2.2 (A), D3.2 (A), J1.2, Q1.2 (D), Q3.2 (D), Q5.2 (D), U1.1 (VCC), U2.1 (VCC), U3.1 (VCC)
GND: C2.2, C3.2, C5.2, C9.2, C10.2, J1.1, J2.1, Q2.3 (S), Q4.3 (S), Q6.3 (S), R4.1, R8.1, R12.1, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, U1.4 (COM), U2.4 (COM), U3.4 (COM)
IN_U: R20.2, U1.2 (IN)
IN_V: R22.2, U2.2 (IN)
IN_W: R24.2, U3.2 (IN)
unnamed: C1.1, D1.1 (K), U1.8 (VB)
unnamed: C4.1, D2.1 (K), U2.8 (VB)
unnamed: C6.1, D3.1 (K), U3.8 (VB)
unnamed: J2.2, R18.1, R24.1
unnamed: J2.3, R17.1, R23.1
unnamed: J2.4, R16.1, R22.1
unnamed: J2.5, R15.1, R21.1
unnamed: J2.6, R14.1, R20.1
unnamed: J2.7, R13.1, R19.1
unnamed: Q1.1 (G), R1.2, R2.2
unnamed: Q2.1 (G), R3.2, R4.2
unnamed: Q3.1 (G), R5.2, R7.2
unnamed: Q4.1 (G), R6.2, R8.2
unnamed: Q5.1 (G), R9.2, R11.2
unnamed: Q6.1 (G), R10.2, R12.2
unnamed: R1.1, U1.7 (HO)
unnamed: R3.1, U1.5 (LO)
unnamed: R5.1, U2.7 (HO)
unnamed: R6.1, U2.5 (LO)
unnamed: R9.1, U3.7 (HO)
unnamed: R10.1, U3.5 (LO)
OUTPUT_U: C1.2, J3.1, Q1.3 (S), Q2.2 (D), R2.1, U1.6 (VS)
OUTPUT_V: C4.2, J3.2, Q3.3 (S), Q4.2 (D), R7.1, U2.6 (VS)
OUTPUT_W: C6.2, J3.3, Q5.3 (S), Q6.2 (D), R11.1, U3.6 (VS)
SD_U: R19.2, U1.3 (~SD)
SD_V: R21.2, U2.3 (~SD)
SD_W: R23.2, U3.3 (~SD)

Board: 2 copper layers, 73.5 x 40.0 mm, 51 parts (0 on the bottom side), 32 nets.

## KiCad design project/motor-driver/dc-for-385-v1/dc-for-385-v1.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 10uF; C_1210_3225Metric
C8, C12, C16, C17, C18: 0.1uF; C_0603_1608Metric
C9, C10: 1uF; C_0805_2012Metric
C11: 10uF; C_0603_1608Metric
C13, C14, C15: 0.01uF; C_0603_1608Metric
C19: 1000pF; C_0402_1005Metric
D1, D2: UDZV5.1B; D_SOD-323
D3: SMBJ45CA; D_SMA
D4: PEC3808C2A; SOT-23
D5, D7: Orange; LED_0603_1608Metric
D6: Blue; LED_0603_1608Metric
M1: RS385
Q1: TJ8S06M3L; TO-252-2
R1, R5, R7, R8: 1kΩ; R_0603_1608Metric
R2, R3, R6: 10kΩ; R_0603_1608Metric
R4: 0.1Ω; R_2512_6332Metric
TP1: Power_VDD; SolderWirePad_1x01_SMD_4x8mm
TP2: Power_GND; SolderWirePad_1x01_SMD_4x8mm
TP3: Input_DIR; TestPoint_Keystone_5015_Micro_Mini
TP4: Input_PWM; TestPoint_Keystone_5015_Micro_Mini
TP5: Input_GND; TestPoint_Keystone_5015_Micro_Mini
TP6: MotorCase; TestPoint_Keystone_5015_Micro_Mini
U1: TB67H450FNG; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U2: AP7375; SOT-23
U3, U4: 74AHC1G08; SOT-23-5
U5: 74AHC1G04; SOT-23-5

Connections:
+3.3V: C11.1, C12.1, C16.1, C17.1, C18.2, R5.1, U1.4 (VREF), U2.2 (VO), U3.5 (VCC), U4.5 (VCC), U5.5 (VCC)
+BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.1, C10.1, C19.1, D1.1 (K), Q1.3 (S), U1.5 (VM), U2.1 (VI)
DIR: R7.2, U4.2, U5.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, C16.2, C17.2, C18.1, D3.1 (A1), D4.3 (common), D6.1 (K), R1.2, R2.2, R3.2, R4.2, TP2.1, TP5.1, U1.1 (GND), U1.9 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND)
IN1: U1.3 (IN1), U3.4
IN2: U1.2 (IN2), U4.4
MOTOR_A: C13.1, C14.2, M1.1 (+), R6.1, U1.6 (OUT1)
MOTOR_B: C14.1, C15.2, D5.2 (A), D7.1 (K), M1.2 (-), U1.8 (OUT2)
unnamed: C13.2, C15.1, TP6.1
unnamed: D1.2 (A), D2.1 (K)
unnamed: C19.2, D2.2 (A), Q1.1 (G), R1.1
unnamed: D3.2 (A2), Q1.2 (D), TP1.1
unnamed: D4.1 (A1), R3.1, R8.1, TP4.1
unnamed: D4.2 (A2), R2.1, R7.1, TP3.1
unnamed: D5.1 (K), D7.2 (A), R6.2
unnamed: D6.2 (A), R5.2
unnamed: R4.1, U1.7 (RS)
unnamed: U3.2, U5.4
PWM: R8.2, U3.1, U4.1

Notes on the sheet:
DCバイアスで容量が下がるので7つで42uF
DCバイアスで0.5uFまで下がるので2つで1uF

Board: 2 copper layers, 32.0 x 36.0 mm, 47 parts (0 on the bottom side), 19 nets.

File project/motor-driver/dc-for-385-v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5, C6, C7",1210,7,10uF,
"C10, C9",0805,2,1uF,
C11,0603,1,10uF,
"C12, C16, C17, C18, C8",0603,5,0.1uF,
"C13, C14, C15",0603,3,0.01uF,
C19,0402,1,1000pF,
"D1, D2",D_SOD-323,2,UDZV5.1B,
D3,D_SMA,1,SMBJ45CA,
D4,SOT-23,1,PEC3808C2A,
"D5, D7",0603,2,Orange,
D6,0603,1,Blue,
M1,RS385,1,RS385,
Q1,TO-252-2,1,TJ8S06M3L,
"R1, R5, R7, R8",0603,4,1kΩ,
"R2, R3, R6",0603,3,10kΩ,
R4,2512,1,0.1Ω,
TP1,SolderWirePad_1x01_SMD_4x8mm,1,Power_VDD,
TP2,SolderWirePad_1x01_SMD_4x8mm,1,Power_GND,
TP3,TestPoint_Keystone_5015_Micro_Mini,1,Input_DIR,
TP4,TestPoint_Keystone_5015_Micro_Mini,1,Input_PWM,
TP5,TestPoint_Keystone_5015_Micro_Mini,1,Input_GND,
TP6,TestPoint_Keystone_5015_Micro_Mini,1,MotorCase,
U1,HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm,1,TB67H450FNG,
U2,SOT-23,1,AP7375,
"U3, U4",SOT-23-5,2,74AHC1G08,
U5,SOT-23-5,1,74AHC1G04,

## KiCad design project/motor-driver/dc-for-385-v2/dc-for-385-v2.kicad_pcb

Parts:
C1, C2: 1uF; C_0805_2012Metric
C3, C4, C6: 0.1uF; C_0603_1608Metric
C5: 0.47uF; C_0805_2012Metric
C7, C8, C9, C10, C11, C12: 10uF; C_1210_3225Metric
D1, D2, D5: CUHS20S60; D_SOD-323
D3, D4, D6: LED; LED_0603_1608Metric
DT1, DT2, DT3: DTC114E; SOT-23
J1: Power; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Output; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Input; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
Q1, Q2, Q3, Q4: TPH11006NL; TDSON-8-1
R1, R3, R5, R7: 10Ω; R_0603_1608Metric
R2, R4, R6, R8, R9, R10, R11, R12, R13: 10kΩ; R_0603_1608Metric
U1, U2: IR2302; SOIC-8_3.9x4.9mm_P1.27mm
U3: L7808; TO-252-2

Connections:
+8V: C3.1, C4.1, C6.1, D1.2 (A), D2.2 (A), D5.2 (A), R13.1, U1.1 (VCC), U2.1 (VCC), U3.3 (OUT)
+BATT: C5.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, D5.1 (K), J1.2, Q1.5 (D), Q3.5 (D), U3.1 (IN)
DIR: DT1.1 (B), DT2.1 (B), J3.3
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D6.1 (K), DT1.2 (E), DT2.2 (E), DT3.2 (E), J1.1, J3.1, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), R4.2, R8.2, U1.4 (COM), U2.4 (COM), U3.2 (GND)
IN_A: DT1.3 (C), R10.2, U1.2 (IN)
IN_B: DT3.3 (C), R12.2, U2.2 (IN)
MOTOR_A: C1.2, D3.1 (K), D4.2 (A), J2.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), R2.2, U1.6 (VS)
MOTOR_B: C2.2, J2.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R6.2, R9.2, U2.6 (VS)
unnamed: C1.1, D1.1 (K), U1.8 (VB)
unnamed: C2.1, D2.1 (K), U2.8 (VB)
unnamed: D3.2 (A), D4.1 (K), R9.1
unnamed: D6.2 (A), R13.2
unnamed: DT2.3 (C), DT3.1 (B), R11.2
unnamed: Q1.4 (G), R1.2, R2.1
unnamed: Q2.4 (G), R3.2, R4.1
unnamed: Q3.4 (G), R5.2, R6.1
unnamed: Q4.4 (G), R7.2, R8.1
unnamed: R1.1, U1.7 (HO)
unnamed: R3.1, U1.5 (LO)
unnamed: R5.1, U2.7 (HO)
unnamed: R7.1, U2.5 (LO)
PWM: J3.2, R10.1, R11.1, R12.1

Board: 2 copper layers, 50.0 x 25.0 mm, 44 parts (1 on the bottom side), 22 nets.

File project/motor-driver/dc-for-385-v2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
,abf7de50-6944-431c-8153-075f1279aee6,1,,
"C1, C2",0805,2,1uF,
"C10, C11, C12, C7, C8, C9",1210,6,10uF,
"C3, C4, C6",0603,3,0.1uF,
C5,0805,1,0.47uF,
"D1, D2, D5",D_SOD-323,3,CUHS20S60,
"D3, D4, D6",0603,3,LED,
"DT1, DT2, DT3",SOT-23,3,DTC114E,
J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,Power,
J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Output,
J3,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Input,
"Q1, Q2, Q3, Q4",TDSON-8-1,4,TPH11006NL,
"R1, R3, R5, R7",0603,4,10Ω,
"R10, R11, R12, R13, R2, R4, R6, R8, R9",0603,9,10kΩ,
"U1, U2",SOIC-8_3.9x4.9mm_P1.27mm,2,IR2302,
U3,TO-252-2,1,L7808,

## KiCad design project/motor-driver/dc-v1/dc-v1.kicad_pcb

Parts:
C1, C2: 1uF; C_0805_2012Metric
C3: 100uF; CP_Radial_D8.0mm_P3.50mm
C4: 47uF; CP_Radial_D6.3mm_P2.50mm
C5: 0.47uF; C_0603_1608Metric
C6, C7, C8, C9, C10, C11, C12, C13: 0.1uF; C_0603_1608Metric
D1, D2: 1N4148W; D_SOD-123
D3, D4, D5: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Power; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: Motor; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Control; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
Q1, Q2, Q3, Q4: NMOS; TO-252-2
R1, R3, R5, R7: 10Ω; R_0603_1608Metric
R2, R4, R6, R8, R9, R10, R13, R14: 10kΩ; R_0603_1608Metric
R11, R12: 1kΩ; R_0603_1608Metric
U1, U2: IR2302; SOIC-8_3.9x4.9mm_P1.27mm
U3: ADuM120N; SOIC-8_3.9x4.9mm_P1.27mm
U4: L7805; TO-252-2
U5: 74AHC1G04; SOT-23-5
U6, U7: 74AHC1G08; SOT-23-5

Connections:
+5V: C6.1, C10.1, C11.1, C12.1, C13.2, R14.2, U3.8 (VDD2), U4.3 (OUT), U5.5 (VCC), U6.5 (VCC), U7.5 (VCC)
+12V: C3.1, C4.1, C5.1, C7.1, C8.1, D1.2 (A), D2.2 (A), J1.2, Q1.2 (D), Q3.2 (D), U1.1 (VCC), U2.1 (VCC), U4.1 (IN)
DIR: R12.2, U5.2, U7.2
GND1: C9.2, J3.1, R9.2, R10.2, U3.4 (GND1)
GND2: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.1, D5.1 (K), J1.1, Q2.3 (S), Q4.3 (S), R4.2, R8.2, U1.4 (COM), U2.4 (COM), U3.5 (GND2), U4.2 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND)
IN_A: U1.2 (IN), U7.4
IN_B: U2.2 (IN), U6.4
MOTOR_A: C1.2, J2.2, Q1.3 (S), Q2.2 (D), R2.2, R13.1, U1.6 (VS)
MOTOR_B: C2.2, D3.2 (A), D4.1 (K), J2.1, Q3.3 (S), Q4.2 (D), R6.2, U2.6 (VS)
unnamed: C1.1, D1.1 (K), U1.8 (VB)
unnamed: C2.1, D2.1 (K), U2.8 (VB)
unnamed: D3.1 (K), D4.2 (A), R13.2
unnamed: D5.2 (A), R14.1
unnamed: J3.2, R10.1, U3.3 (VIB)
unnamed: J3.3, R9.1, U3.2 (VIA)
unnamed: Q1.1 (G), R1.2, R2.1
unnamed: Q2.1 (G), R3.2, R4.1
unnamed: Q3.1 (G), R5.2, R6.1
unnamed: Q4.1 (G), R7.2, R8.1
unnamed: R1.1, U1.7 (HO)
unnamed: R3.1, U1.5 (LO)
unnamed: R5.1, U2.7 (HO)
unnamed: R7.1, U2.5 (LO)
unnamed: R11.1, U3.7 (VOA)
unnamed: R12.1, U3.6 (VOB)
unnamed: U5.4, U6.2
PWM: R11.2, U6.1, U7.1
VCC: C9.1, J3.4, U3.1 (VDD1)

Board: 2 copper layers, 61.0 x 43.0 mm, 50 parts (0 on the bottom side), 28 nets.

File project/motor-driver/dc-v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0805,2,1uF,
"C10, C11, C12, C13, C6, C7, C8, C9",0603,8,0.1uF,
C3,CP_Radial_D8.0mm_P3.50mm,1,100uF,
C4,CP_Radial_D6.3mm_P2.50mm,1,47uF,
C5,0603,1,0.47uF,
"D1, D2",D_SOD-123,2,1N4148W,
"D3, D4, D5",0603,3,LED,
J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,Power,
J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Motor,
J3,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,1,Control,
"Q1, Q2, Q3, Q4",TO-252-2,4,NMOS,
"R1, R3, R5, R7",0603,4,10Ω,
"R10, R13, R14, R2, R4, R6, R8, R9",0603,8,10kΩ,
"R11, R12",0603,2,1kΩ,
"U1, U2",SOIC-8_3.9x4.9mm_P1.27mm,2,IR2302,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,ADuM120N,
U4,TO-252-2,1,L7805,
U5,SOT-23-5,1,74AHC1G04,
"U6, U7",SOT-23-5,2,74AHC1G08,
