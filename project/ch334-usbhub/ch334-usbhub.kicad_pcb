# Repository Netetra/kicad-archive

## KiCad design project/ch334-usbhub/ch334-usbhub.kicad_pcb

Parts:
C1: 470uF25V125℃ PZJ; CP_Radial_D10.0mm_P5.00mm
C2: 0.1uF; C_0603_1608Metric
C3: 1uF; C_0603_1608Metric
C4, C6, C8, C9: 100uF; CP_Radial_D10.0mm_P5.00mm
C5, C7, C10, C11: 10uF; C_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2, J3, J4, J5: USB_A; USB_A_Molex_67643_Horizontal
R1, R2: 5.1kΩ; R_0603_1608Metric
R3, R4, R5, R6: 56kΩ; R_0603_1608Metric
U1: CH334R; QSOP-16_3.9x4.9mm_P0.635mm
U2, U3, U5, U7, U8: USBLC6-2SC6; SOT-23-6
U4, U6, U9, U10: CH217; SOT-23-6

Connections:
+5V: C1.1, C2.2, C5.1, C7.1, C10.1, C11.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.12 (V5), U2.5 (VBUS), U4.6 (VIN), U6.6 (VIN), U9.6 (VIN), U10.6 (VIN)
DP1+: U1.8 (DP1+), U3.6 (I/O1)
DP1-: U1.7 (DM1-), U3.4 (I/O2)
DP2+: U1.6 (DP2+), U5.6 (I/O1)
DP2-: U1.5 (DM2-), U5.4 (I/O2)
DP3+: U1.4 (DP3+), U7.6 (I/O1)
DP3-: U1.3 (DM3-), U7.4 (I/O2)
DP4+: U1.2 (DP4+), U8.6 (I/O1)
DP4-: U1.1 (DM4-), U8.4 (I/O2)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4 (GND), J2.5 (Shield), J3.4 (GND), J3.5 (Shield), J4.4 (GND), J4.5 (Shield), J5.4 (GND), J5.5 (Shield), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U1.14 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U4.4 (EN#), U5.2 (GND), U6.2 (GND), U6.4 (EN#), U7.2 (GND), U8.2 (GND), U9.2 (GND), U9.4 (EN#), U10.2 (GND), U10.4 (EN#)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J1.A6 (D+), J1.B6 (D+), U2.3 (I/O2)
unnamed: J1.A7 (D-), J1.B7 (D-), U2.1 (I/O1)
unnamed: J2.3 (D+), U3.1 (I/O1)
unnamed: J2.2 (D-), U3.3 (I/O2)
unnamed: C4.1, J2.1 (VBUS), U3.5 (VBUS), U4.1 (VOUT)
unnamed: J3.3 (D+), U5.1 (I/O1)
unnamed: J3.2 (D-), U5.3 (I/O2)
unnamed: C6.1, J3.1 (VBUS), U5.5 (VBUS), U6.1 (VOUT)
unnamed: J4.3 (D+), U7.1 (I/O1)
unnamed: J4.2 (D-), U7.3 (I/O2)
unnamed: C8.1, J4.1 (VBUS), U7.5 (VBUS), U9.1 (VOUT)
unnamed: J5.3 (D+), U8.1 (I/O1)
unnamed: J5.2 (D-), U8.3 (I/O2)
unnamed: C9.1, J5.1 (VBUS), U8.5 (VBUS), U10.1 (VOUT)
unnamed: C3.2, U1.13 (VDD33)
unnamed: R3.1, U4.5 (ISET)
unnamed: R4.1, U6.5 (ISET)
unnamed: R5.1, U9.5 (ISET)
unnamed: R6.1, U10.5 (ISET)
UP+: U1.11 (DPU+), U2.4 (I/O2)
UP-: U1.10 (DMU-), U2.6 (I/O1)

Notes on the sheet:
Iset=60/56=1A制限

Board: 2 copper layers, 95.0 x 30.0 mm, 32 parts (16 on the bottom side), 33 nets.

## KiCad design project/ch552-daplink/ch552-daplink.kicad_pcb

Board: 2 copper layers, 22.0 x 11.5 mm, 21 parts (0 on the bottom side), 17 nets.

Parts:
C1, C2: 0.1uF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
D2: Green; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J3: BOOT; PinSocket_1x02_P1.00mm_Vertical
R1, R2: 5.1kΩ; R_0603_1608Metric
R3, R4: 1kΩ; R_0603_1608Metric
R5: 10kΩ; R_0603_1608Metric
R6, R7, R8: 100Ω; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; SolderWirePad_1x01_SMD_1x2mm
U1: CH552E; MSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C1.1, J3.2, R3.2, R4.2, TP5.1, U1.10 (V33)
+5V: C2.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP6.1, U1.9 (VCC)
D+: J1.A6 (D+), J1.B6 (D+), R5.1, U1.6 (UDP)
D-: J1.A7 (D-), J1.B7 (D-), U1.7 (UDM)
GND: C1.2, C2.2, D1.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.2, TP1.1, U1.8 (GND)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R4.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J3.1, R5.2
unnamed: R6.1, TP4.1
unnamed: R7.2, TP3.1
unnamed: R8.2, TP2.1
PRG_LED: D2.1 (K), U1.1 (P1.4)
RST: R8.1, U1.2 (P1.5)
SWCLK: R6.2, U1.4 (P1.7)
SWDIO: R7.1, U1.3 (P1.6)

File project/ch552-daplink/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1_32, C1_31, C1_30, C1_29, C1_28, C1_27, C1_26, C1_25, C1_24, C1_23, C1_22, C1_21, C1_20, C1_19, C1_18, C1_17, C1_16, C1_15, C1_14, C1_13, C1_12, C1_11, C1_10, C1_9, C1_8, C1_7, C1_6, C1_5, C1_4, C1_3, C1_2, C1, C2_32, C2_31, C2_30, C2_29, C2_28, C2_27, C2_26, C2_25, C2_24, C2_23, C2_22, C2_21, C2_20, C2_19, C2_18, C2_17, C2_16, C2_15, C2_14, C2_13, C2_12, C2_11, C2_10, C2_9, C2_8, C2_7, C2_6, C2_5, C2_4, C2_3, C2_2, C2",0603,64,0.1uF,
"D1_32, D1_31, D1_30, D1_29, D1_28, D1_27, D1_26, D1_25, D1_24, D1_23, D1_22, D1_21, D1_20, D1_19, D1_18, D1_17, D1_16, D1_15, D1_14, D1_13, D1_12, D1_11, D1_10, D1_9, D1_8, D1_7, D1_6, D1_5, D1_4, D1_3, D1_2, D1",0603,32,Blue,
"D2_32, D2_31, D2_30, D2_29, D2_28, D2_27, D2_26, D2_25, D2_24, D2_23, D2_22, D2_21, D2_20, D2_19, D2_18, D2_17, D2_16, D2_15, D2_14, D2_13, D2_12, D2_11, D2_10, D2_9, D2_8, D2_7, D2_6, D2_5, D2_4, D2_3, D2_2, D2",0603,32,Green,
"J1_32, J1_31, J1_30, J1_29, J1_28, J1_27, J1_26, J1_25, J1_24, J1_23, J1_22, J1_21, J1_20, J1_19, J1_18, J1_17, J1_16, J1_15, J1_14, J1_13, J1_12, J1_11, J1_10, J1_9, J1_8, J1_7, J1_6, J1_5, J1_4, J1_3, J1_2, J1",USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,32,USB_C_Receptacle_USB2.0_16P,
"J3_32, J3_31, J3_30, J3_29, J3_28, J3_27, J3_26, J3_25, J3_24, J3_23, J3_22, J3_21, J3_20, J3_19, J3_18, J3_17, J3_16, J3_15, J3_14, J3_13, J3_12, J3_11, J3_10, J3_9, J3_8, J3_7, J3_6, J3_5, J3_4, J3_3, J3_2, J3",PinSocket_1x02_P1.00mm_Vertical,32,BOOT,
"R1_32, R1_31, R1_30, R1_29, R1_28, R1_27, R1_26, R1_25, R1_24, R1_23, R1_22, R1_21, R1_20, R1_19, R1_18, R1_17, R1_16, R1_15, R1_14, R1_13, R1_12, R1_11, R1_10, R1_9, R1_8, R1_7, R1_6, R1_5, R1_4, R1_3, R1_2, R1, R2_32, R2_31, R2_30, R2_29, R2_28, R2_27, R2_26, R2_25, R2_24, R2_23, R2_22, R2_21, R2_20, R2_19, R2_18, R2_17, R2_16, R2_15, R2_14, R2_13, R2_12, R2_11, R2_10, R2_9, R2_8, R2_7, R2_6, R2_5, R2_4, R2_3, R2_2, R2",0603,64,5.1kΩ,
"R3_32, R3_31, R3_30, R3_29, R3_28, R3_27, R3_26, R3_25, R3_24, R3_23, R3_22, R3_21, R3_20, R3_19, R3_18, R3_17, R3_16, R3_15, R3_14, R3_13, R3_12, R3_11, R3_10, R3_9, R3_8, R3_7, R3_6, R3_5, R3_4, R3_3, R3_2, R3, R4_32, R4_31, R4_30, R4_29, R4_28, R4_27, R4_26, R4_25, R4_24, R4_23, R4_22, R4_21, R4_20, R4_19, R4_18, R4_17, R4_16, R4_15, R4_14, R4_13, R4_12, R4_11, R4_10, R4_9, R4_8, R4_7, R4_6, R4_5, R4_4, R4_3, R4_2, R4",0603,64,1kΩ,
"R5_32, R5_31, R5_30, R5_29, R5_28, R5_27, R5_26, R5_25, R5_24, R5_23, R5_22, R5_21, R5_20, R5_19, R5_18, R5_17, R5_16, R5_15, R5_14, R5_13, R5_12, R5_11, R5_10, R5_9, R5_8, R5_7, R5_6, R5_5, R5_4, R5_3, R5_2, R5",0603,32,10kΩ,
"R6_32, R6_31, R6_30, R6_29, R6_28, R6_27, R6_26, R6_25, R6_24, R6_23, R6_22, R6_21, R6_20, R6_19, R6_18, R6_17, R6_16, R6_15, R6_14, R6_13, R6_12, R6_11, R6_10, R6_9, R6_8, R6_7, R6_6, R6_5, R6_4, R6_3, R6_2, R6, R7_32, R7_31, R7_30, R7_29, R7_28, R7_27, R7_26, R7_25, R7_24, R7_23, R7_22, R7_21, R7_20, R7_19, R7_18, R7_17, R7_16, R7_15, R7_14, R7_13, R7_12, R7_11, R7_10, R7_9, R7_8, R7_7, R7_6, R7_5, R7_4, R7_3, R7_2, R7, R8_32, R8_31, R8_30, R8_29, R8_28, R8_27, R8_26, R8_25, R8_24, R8_23, R8_22, R8_21, R8_20, R8_19, R8_18, R8_17, R8_16, R8_15, R8_14, R8_13, R8_12, R8_11, R8_10, R8_9, R8_8, R8_7, R8_6, R8_5, R8_4, R8_3, R8_2, R8",0603,96,100Ω,
"TP1_32, TP1_31, TP1_30, TP1_29, TP1_28, TP1_27, TP1_26, TP1_25, TP1_24, TP1_23, TP1_22, TP1_21, TP1_20, TP1_19, TP1_18, TP1_17, TP1_16, TP1_15, TP1_14, TP1_13, TP1_12, TP1_11, TP1_10, TP1_9, TP1_8, TP1_7, TP1_6, TP1_5, TP1_4, TP1_3, TP1_2, TP1, TP2_32, TP2_31, TP2_30, TP2_29, TP2_28, TP2_27, TP2_26, TP2_25, TP2_24, TP2_23, TP2_22, TP2_21, TP2_20, TP2_19, TP2_18, TP2_17, TP2_16, TP2_15, TP2_14, TP2_13, TP2_12, TP2_11, TP2_10, TP2_9, TP2_8, TP2_7, TP2_6, TP2_5, TP2_4, TP2_3, TP2_2, TP2, TP3_32, TP3_31, TP3_30, TP3_29, TP3_28, TP3_27, TP3_26, TP3_25, TP3_24, TP3_23, TP3_22, TP3_21, TP3_20, TP3_19, TP3_18, TP3_17, TP3_16, TP3_15, TP3_14, TP3_13, TP3_12, TP3_11, TP3_10, TP3_9, TP3_8, TP3_7, TP3_6, TP3_5, TP3_4, TP3_3, TP3_2, TP3, TP4_32, TP4_31, TP4_30, TP4_29, TP4_28, TP4_27, TP4_26, TP4_25, TP4_24, TP4_23, TP4_22, TP4_21, TP4_20, TP4_19, TP4_18, TP4_17, TP4_16, TP4_15, TP4_14, TP4_13, TP4_12, TP4_11, TP4_10, TP4_9, TP4_8, TP4_7, TP4_6, TP4_5, TP4_4, TP4_3, TP4_2, TP4, TP5_32, TP5_31, TP5_30, TP5_29, TP5_28, TP5_27, TP5_26, TP5_25, TP5_24, TP5_23, TP5_22, TP5_21, TP5_20, TP5_19, TP5_18, TP5_17, TP5_16, TP5_15, TP5_14, TP5_13, TP5_12, TP5_11, TP5_10, TP5_9, TP5_8, TP5_7, TP5_6, TP5_5, TP5_4, TP5_3, TP5_2, TP5, TP6_32, TP6_31, TP6_30, TP6_29, TP6_28, TP6_27, TP6_26, TP6_25, TP6_24, TP6_23, TP6_22, TP6_21, TP6_20, TP6_19, TP6_18, TP6_17, TP6_16, TP6_15, TP6_14, TP6_13, TP6_12, TP6_11, TP6_10, TP6_9, TP6_8, TP6_7, TP6_6, TP6_5, TP6_4, TP6_3, TP6_2, TP6",SolderWirePad_1x01_SMD_1x2mm,192,TestPoint,
"U1_32, U1_31, U1_30, U1_29, U1_28, U1_27, U1_26, U1_25, U1_24, U1_23, U1_22, U1_21, U1_20, U1_19, U1_18, U1_17, U1_16, U1_15, U1_14, U1_13, U1_12, U1_11, U1_10, U1_9, U1_8, U1_7, U1_6, U1_5, U1_4, U1_3, U1_2, U1",MSOP-10_3x3mm_P0.5mm,32,CH552E,

## KiCad design project/dcdc/xc9704b75cpr-g/xc9704b75cpr-g.kicad_pcb

Board: 2 copper layers, 40.0 x 18.0 mm, 10 parts (0 on the bottom side), 5 nets.

Parts:
C1: 4.7uF; C_1210_3225Metric
C2, C3: 10uF; C_1210_3225Metric
C7: 20pF; C_0603_1608Metric
J1: Input; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2: Output; AMASS_XT60-F_1x02_P7.20mm_Vertical
L1: 10uH; L_1210_3225Metric
R1: 11kΩ; R_0603_1608Metric
R2: 1kΩ; R_0603_1608Metric
U1: XC9704B75CPR-G; SOT-89-5

Connections:
+9V: C2.1, C3.1, C7.2, J2.2, L1.2, R1.1
+BATT: C1.1, J1.2, U1.4 (EN/SS), U1.5 (VIN)
GND: C1.2, C2.2, C3.2, J1.1, J2.1, R2.1, U1.2 (GND)
unnamed: C7.1, R1.2, R2.2, U1.3 (FB)
unnamed: L1.1, U1.1 (Lx)

## KiCad design project/f303k8-led-matrix/f303k8-led-matrix.kicad_pcb

Board: 2 copper layers, 62.0 x 20.0 mm, 103 parts (4 on the bottom side), 48 nets.

Parts:
3V3: TX; TestPoint_Pad_D1.0mm
C1, C2, C3, C6, C7, C8: 0.1uF; C_0603_1608Metric
C4: 0.47uF; C_0603_1608Metric
C5: 4.7uF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
D2: Yellow; LED_0603_1608Metric
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: Red; LED_0603_1608Metric
GND: RX; TestPoint_Pad_D1.0mm
H1: MountingHole; MountingHole_2.2mm_M2
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: Boot; PinHeader_1x02_P1.27mm_Vertical
R1, R2: 5.1kΩ; R_0603_1608Metric
R3, R7: 10kΩ; R_0603_1608Metric
R4, R5, R6: 100Ω; R_0603_1608Metric
R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1kΩ; R_0603_1608Metric
RX: RX; TestPoint_Pad_D1.0mm
TX: TX; TestPoint_Pad_D1.0mm
U1: USBLC6-2SC6; SOT-23-6
U2: CH552E; MSOP-10_3x3mm_P0.5mm
U3: CH213K; SOT-23-3
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U5: NJM12888; SOT-23-5

Connections:
+3.3V: 3V3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J2.2, R8.1, R9.1, U4.1 (VDD), U4.5 (VDDA), U4.17 (VDD), U5.5 (Vout)
COL_A: R10.1, U4.13 (PA7)
COL_B: R11.1, U4.12 (PA6)
COL_C: R12.1, U4.10 (PA4)
COL_D: R13.1, U4.7 (PA1)
COL_E: R14.1, U4.25 (PA15)
COL_F: R15.1, U4.26 (PB3)
COL_G: R16.1, U4.27 (PB4)
COL_H: R17.1, U4.28 (PB5)
D+: R7.2, U1.4 (I/O2), U2.6 (UDP)
D-: U1.6 (I/O1), U2.7 (UDM)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), GND.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R1.2, R2.1, R3.1, U1.2 (GND), U2.8 (GND), U3.1 (GND), U4.16 (VSS), U4.32 (VSS), U5.2 (GND)
NRST: R4.1, U4.4 (NRST)
unnamed: D1.2 (A), R8.2
unnamed: D2.2 (A), R9.2
unnamed: D9.2 (A), D10.2 (A), D25.2 (A), D26.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), R13.2
unnamed: D11.2 (A), D12.2 (A), D27.2 (A), D28.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), R14.2
unnamed: D13.2 (A), D14.2 (A), D29.2 (A), D30.2 (A), D55.2 (A), D56.2 (A), D57.2 (A), D58.2 (A), R15.2
unnamed: D15.2 (A), D16.2 (A), D31.2 (A), D32.2 (A), D59.2 (A), D60.2 (A), D61.2 (A), D62.2 (A), R16.2
unnamed: D17.2 (A), D18.2 (A), D33.2 (A), D34.2 (A), D63.2 (A), D64.2 (A), D65.2 (A), D66.2 (A), R17.2
unnamed: D3.2 (A), D4.2 (A), D19.2 (A), D20.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), R10.2
unnamed: D5.2 (A), D6.2 (A), D21.2 (A), D22.2 (A), D39.2 (A), D40.2 (A), D41.2 (A), D42.2 (A), R11.2
unnamed: D7.2 (A), D8.2 (A), D23.2 (A), D24.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D46.2 (A), R12.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.2
unnamed: J1.A6 (D+), J1.B6 (D+), U1.3 (I/O2)
unnamed: J1.A7 (D-), J1.B7 (D-), U1.1 (I/O1)
unnamed: J2.1, R7.1
unnamed: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS), U3.3 (VI+)
unnamed: R4.2, U2.2 (P1.5)
unnamed: R5.2, U2.3 (P1.6)
unnamed: R6.2, U2.4 (P1.7)
unnamed: C2.1, U2.10 (V33)
unnamed: R3.2, U4.31 (BOOT0)
PRG_LED: D2.1 (K), U2.1 (P1.4)
ROW_A: D3.1 (K), D5.1 (K), D7.1 (K), D9.1 (K), D11.1 (K), D13.1 (K), D15.1 (K), D17.1 (K), U4.29 (PB6)
ROW_B: D4.1 (K), D6.1 (K), D8.1 (K), D10.1 (K), D12.1 (K), D14.1 (K), D16.1 (K), D18.1 (K), U4.30 (PB7)
ROW_C: D19.1 (K), D21.1 (K), D23.1 (K), D25.1 (K), D27.1 (K), D29.1 (K), D31.1 (K), D33.1 (K), U4.22 (PA12)
ROW_D: D20.1 (K), D22.1 (K), D24.1 (K), D26.1 (K), D28.1 (K), D30.1 (K), D32.1 (K), D34.1 (K), U4.21 (PA11)
ROW_E: D35.1 (K), D39.1 (K), D43.1 (K), D47.1 (K), D51.1 (K), D55.1 (K), D59.1 (K), D63.1 (K), U4.20 (PA10)
ROW_F: D36.1 (K), D40.1 (K), D44.1 (K), D48.1 (K), D52.1 (K), D56.1 (K), D60.1 (K), D64.1 (K), U4.19 (PA9)
ROW_G: D37.1 (K), D41.1 (K), D45.1 (K), D49.1 (K), D53.1 (K), D57.1 (K), D61.1 (K), D65.1 (K), U4.18 (PA8)
ROW_H: D38.1 (K), D42.1 (K), D46.1 (K), D50.1 (K), D54.1 (K), D58.1 (K), D62.1 (K), D66.1 (K), U4.14 (PB0)
RX: RX.1, U4.9 (PA3)
SWCLK: R6.1, U4.24 (PA14)
SWDIO: R5.1, U4.23 (PA13)
TX: TX.1, U4.8 (PA2)
VBUS: C1.1, C3.1, U2.9 (VCC), U3.2 (VO-), U5.1 (Vin), U5.3 (Control)
