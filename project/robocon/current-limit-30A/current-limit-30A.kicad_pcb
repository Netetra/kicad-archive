# Repository Netetra/kicad-archive

File README.md:

# Kicad archive
- `project/` 回路図・基盤データ
- `library/` シンボルやフットプリント
- `template/` テンプレートプロジェクト

## KiCad design project/robocon/current-limit-30A/current-limit-30A.kicad_pcb

Parts:
C1, C3, C4, C6: 0.1uF; C_0603_1608Metric
C2: 820pF; C_0603_1608Metric
C5: 0.47uF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
D2: Orange; LED_0603_1608Metric
J1: Input; JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal
J2: MD; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J3: IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J4: OUT; AMASS_XT60-F_1x02_P7.20mm_Vertical
R1, R4: 10kΩ; R_0603_1608Metric
R5, R6: 1kΩ; R_0603_1608Metric
U1: CZ3A04; AKM_CZ_SSOP-alt
U2: 74AHC1G08; SOT-23-5
U3: NJM12888; SOT-23-5
U4: NJU77701F; SOT-23-5

Connections:
+3.3V: C1.2, C3.1, C5.1, C6.1, R5.1, U1.7 (VDD), U2.5 (VCC), U3.5 (Vout), U4.5 (V+)
+5V: C4.1, J1.5, U3.1 (Vin), U3.3 (Control)
DIR: J1.3, J2.2
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1 (K), D2.1 (K), J1.1, J2.1, R4.2, U1.3 (VSS), U1.8 (REF1), U1.9 (REF2), U1.10 (VSS), U2.3 (GND), U3.2 (GND), U4.2 (V-)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: J3.1, J4.1
unnamed: J3.2, U1.1 (IP)
unnamed: J4.2, U1.2 (IN)
unnamed: R1.1, U1.6 (VOUT)
OCD: R6.1, U2.1, U4.1
PWM: J1.2, U2.2
PWM': J2.3, U2.4
VOUT: C2.1, R1.2, U4.4 (-)
VREF: J1.4, R4.1, U4.3 (+)

Board: 2 copper layers, 44.0 x 35.0 mm, 20 parts (0 on the bottom side), 15 nets.

File project/robocon/current-limit-30A/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C3, C4, C6",0603,4,0.1uF,
C2,0603,1,820pF,
C5,0603,1,0.47uF,
D1,0603,1,Blue,
D2,0603,1,Orange,
J1,JST_XH_S5B-XH-A_1x05_P2.50mm_Horizontal,1,Input,
J2,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,MD,
J3,AMASS_XT60-M_1x02_P7.20mm_Vertical,1,IN,
J4,AMASS_XT60-F_1x02_P7.20mm_Vertical,1,OUT,
"R1, R4",0603,2,10kΩ,
"R5, R6",0603,2,1kΩ,
U1,AKM_CZ_SSOP-alt,1,CZ3A04,
U2,SOT-23-5,1,74AHC1G08,
U3,SOT-23-5,1,NJM12888,
U4,SOT-23-5,1,NJU77701F,

## KiCad design project/hobbies/capacitor-array/capacitor-array.kicad_pcb

Parts:
C1: 0.01uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C2: 0.1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C3: 1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C4: 4.7uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C5: 10uF; CP_Radial_D5.0mm_P2.50mm
C6: 47uF; CP_Radial_D5.0mm_P2.50mm
C7: 100uF; CP_Radial_D8.0mm_P3.50mm
C8: 22uF; CP_Radial_D5.0mm_P2.50mm
J1: Conn_01x02_Socket; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J2: Conn_01x02_Socket; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal

Connections:
unnamed: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.1, J2.1
unnamed: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J1.2, J2.2

Board: 2 copper layers, 78.0 x 20.0 mm, 10 parts (0 on the bottom side), 2 nets.

## KiCad design project/robocon/stm32f303-module/stm32f303-module.kicad_pcb

Parts:
C1, C4, C5, C6, C9, C10: 0.1uF; C_0603_1608Metric
C2: 0.22uF; C_0603_1608Metric
C3: 4.7uF; C_0603_1608Metric
C7, C8: 20pF; C_0603_1608Metric
D1: Blue; LED_0603_1608Metric
J1, J2: GPIO; PinHeader_1x12_P2.54mm_Vertical
R1: 1kΩ; R_0603_1608Metric
R4: 10kΩ; R_0603_1608Metric
U2: NJM12888; SOT-23-5
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U5: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, R1.1, U2.5 (Vout), U4.1 (VDD), U4.5 (VDDA), U4.17 (VDD), U5.5 (Vio)
+5V: C1.1, C9.2, J1.12, U2.1 (Vin), U2.3 (Control), U5.3 (VDD)
BOOT0: R4.2, U4.31 (BOOT0)
CAN+: J2.11, U5.7 (CANH)
CAN-: J2.12, U5.6 (CANL)
CAN_RX: U4.21 (PA11), U5.4 (RXD)
CAN_TX: U4.22 (PA12), U5.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.2, D1.1 (K), J2.10, R4.1, U2.2 (GND), U4.16 (VSS), U4.32 (VSS), U5.2 (VSS), U5.8 (STBY)
NRST: J2.7, U4.4 (NRST)
unnamed: D1.2 (A), R1.2
OSC_IN: C7.2, U4.2 (PF0), Y1.2
OSC_OUT: C8.2, U4.3 (PF1), Y1.1
PA0: J1.1, U4.6 (PA0)
PA1: J1.2, U4.7 (PA1)
PA2: U4.8 (PA2)
PA3: U4.9 (PA3)
PA4: J1.3, U4.10 (PA4)
PA5: J1.4, U4.11 (PA5)
PA6: J1.5, U4.12 (PA6)
PA7: J1.6, U4.13 (PA7)
PA8: J1.9, U4.18 (PA8)
PA9: J1.10, U4.19 (PA9)
PA10: J1.11, U4.20 (PA10)
PA15: J2.6, U4.25 (PA15)
PB0: J1.7, U4.14 (PB0)
PB1: J1.8, U4.15 (PB1)
PB3: J2.5, U4.26 (PB3)
PB4: J2.4, U4.27 (PB4)
PB5: J2.3, U4.28 (PB5)
PB6: J2.2, U4.29 (PB6)
PB7: J2.1, U4.30 (PB7)
SWCLK: J2.8, U4.24 (PA14)
SWDIO: J2.9, U4.23 (PA13)

Board: 2 copper layers, 31.7 x 21.6 mm, 19 parts (2 on the bottom side), 31 nets.

## KiCad design project/robocon/can-module/can-module.kicad_pcb

Parts:
C1, C2: 0.1uF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
J1: IO; PinHeader_1x07_P2.54mm_Horizontal
R1: 120Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, J1.4, U1.5 (Vio)
+5V: C2.2, J1.3, U1.3 (VDD)
CAN+: J1.6, R1.1, U1.7 (CANH)
CAN-: J1.7, SW1.3 (C), U1.6 (CANL)
GND: C1.2, C2.1, J1.5, U1.2 (VSS), U1.8 (STBY)
unnamed: R1.2, SW1.2 (B)
RX: J1.2, U1.4 (RXD)
TX: J1.1, U1.1 (TXD)

Board: 2 copper layers, 20.0 x 20.0 mm, 6 parts (1 on the bottom side), 8 nets.

## KiCad design project/robocon/esp32s3-test-board/esp32s3-test-board.kicad_pcb

Parts:
C1, C2: 0.1uF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3: 100uF; CP_Radial_D6.3mm_P2.50mm
D1: LED; LED_D5.0mm
J1, J2, J3: AMT22; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J4, J5, J6: AMT102; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J7, J8, J9: MD; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J10, J11, J12: LimitSW; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13, J14: GPIO; PinSocket_1x22_P2.54mm_Vertical
J15, J16, J17: C620; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J18: Power&CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J19: mcp25625_breakout; PinSocket_1x11_P2.54mm_Vertical
R1, R2, R3, R5: 1kΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 120Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: ESP32-S3-DevKitC
U2: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3.3V: C2.1, J13.1, J13.2, J19.5, R1.1, R2.1, R3.1, R5.1, U1.1 (3V3), U1.2 (3V3), U2.5 (Vio)
+5V: C1.2, C3.1, J1.6, J2.6, J3.6, J4.4, J5.4, J6.4, J13.21, J18.4, J19.4, U1.21 (5V), U2.3 (VDD)
A0: J4.3, J13.17, U1.17 (GPIO11/ADC2_CH0)
A1: J5.3, J14.17, U1.28 (GPIO47)
A2: J6.3, J14.10, U1.35 (GPIO38)
B0: J4.5, J13.18, U1.18 (GPIO12/ADC2_CH1)
B1: J5.5, J14.18, U1.27 (GPIO21)
B2: J6.5, J14.16, U1.29 (GPIO48)
CAN0+: J18.2, U2.7 (CANH)
CAN0-: J18.1, U2.6 (CANL)
CAN0_RX: J13.20, U1.20 (GPIO14/ADC2_CH3), U2.4 (RXD)
CAN0_TX: J13.19, U1.19 (GPIO13/ADC2_CH2), U2.1 (TXD)
CAN1+: J15.2, J16.2, J17.2, J19.2, R4.1
CAN1-: J15.1, J16.1, J17.1, J19.1, R4.2
CHIP_PU: J13.3, U1.3 (CHIP_PU)
CS0: J1.1, J13.12, U1.12 (GPIO8/ADC1_CH7)
CS1: J2.1, J13.11, U1.11 (GPIO18/ADC2_CH7)
CS2: J3.1, J13.10, U1.10 (GPIO17/ADC2_CH6)
CS3: J13.15, J19.8, U1.15 (GPIO9/ADC1_CH8)
DIR0: J7.3, J14.9, U1.36 (GPIO39/MTCK)
DIR1: J8.3, J14.7, U1.38 (GPIO41/MTDI)
DIR3: J9.3, J14.4, U1.41 (GPIO1/ADC1_CH0)
GND: C1.1, C2.2, C3.2, D1.1 (K), J1.2, J2.2, J3.2, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.2, J11.2, J12.2, J13.22, J14.1, J14.21, J14.22, J18.3, J19.3, U1.22 (GND), U1.23 (GND), U1.24 (GND), U1.44 (GND), U2.2 (VSS), U2.8 (STBY)
GPIO0: J14.14, U1.31 (GPIO0)
GPIO3: J13.13, U1.13 (GPIO3/ADC1_CH2)
GPIO19: J14.20, U1.25 (GPIO19/USB_D-)
GPIO20: J14.19, U1.26 (GPIO20/USB_D+)
GPIO35: J14.13, U1.32 (GPIO35)
GPIO36: J14.12, U1.33 (GPIO36)
GPIO37: J14.11, U1.34 (GPIO37)
GPIO43: J14.2, U1.43 (GPIO43/U0TXD)
GPIO44: J14.3, U1.42 (GPIO44/U0RXD)
GPIO45: J14.15, U1.30 (GPIO45)
GPIO46: J13.14, U1.14 (GPIO46)
MISO: J1.4, J2.4, J3.4, J13.8, J19.10, U1.8 (GPIO15/ADC2_CH4/32K_P)
MOSI: J1.3, J2.3, J3.3, J13.9, J19.9, U1.9 (GPIO16/ADC2_CH5/32K_N)
unnamed: D1.2 (A), R5.2
PWM0: J7.2, J14.8, U1.37 (GPIO40/MTDO)
PWM1: J8.2, J14.6, U1.39 (GPIO42/MTMS)
PWM3: J9.2, J14.5, U1.40 (GPIO2/ADC1_CH1)
RST: J13.16, J19.6, U1.16 (GPIO10/ADC1_CH9)
SCLK: J1.5, J2.5, J3.5, J13.7, J19.11, U1.7 (GPIO7/ADC1_CH6)
SW0: J10.1, J13.4, R1.2, U1.4 (GPIO4/ADC1_CH3)
SW1: J11.1, J13.5, R2.2, U1.5 (GPIO5/ADC1_CH4)
SW2: J12.1, J13.6, R3.2, U1.6 (GPIO6/ADC1_CH5)

Notes on the sheet:
mcp25625-breakoutの基板上の終端抵抗を使用してください

Board: 2 copper layers, 100.0 x 70.0 mm, 30 parts (0 on the bottom side), 45 nets.

## KiCad design project/robocon/can-power-hub/can-power-hub.kicad_pcb

Parts:
D1: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3, J4, J5, J6: Connector; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
R1: 1kΩ; R_0603_1608Metric

Connections:
+5V: J1.4, J2.4, J3.4, J4.4, J5.4, J6.4, R1.1
CAN+: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2
CAN-: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1
GND: D1.1 (K), J1.3, J2.3, J3.3, J4.3, J5.3, J6.3
unnamed: D1.2 (A), R1.2

Board: 2 copper layers, 85.0 x 25.0 mm, 12 parts (0 on the bottom side), 5 nets.

File project/robocon/can-power-hub/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
D1,0603,1,LED,
"J1, J2, J3, J4, J5, J6",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,6,Connector,
R1,0603,1,1kΩ,

## KiCad design project/robocon/esp32s3-main-v1/esp32s3-main-v1.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1uF; C_0603_1608Metric
C6: 100uF; CP_Radial_D6.3mm_P2.50mm
D1: LED; LED_0603_1608Metric
H1: MountingHole; MountingHole_3.2mm_M3
J1: PowerSupply & Programming; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: CAN; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J3: Controller; USB_A_Molex_67643_Horizontal
J4: GPIO; JST_XH_B9B-XH-A_1x09_P2.50mm_Vertical
R1, R2: 5.1kΩ; R_0603_1608Metric
R3: 120Ω; R_0603_1608Metric
R4, R5: 22Ω; R_0603_1608Metric
R6: 1kΩ; R_0603_1608Metric
U1: XIAO-ESP32-S3-SMD
U2: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3, U4: USBLC6-2SC6; SOT-23-6
U5: CH340N; JEITA_SOIC-8_3.9x4.9mm_P1.27mm

Connections:
'ESP_D+: R5.1, U1.22 (USB_DP)
'ESP_D-: R4.1, U1.21 (USB_DN)
+3.3V: C2.1, U1.12 (3V3_OUT), U2.5 (Vio)
+5V: C1.1, C3.1, C5.1, C6.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.4, J3.1 (VBUS), J4.9, R6.1, U1.14 (VBUS), U2.3 (VDD), U3.5 (VBUS), U4.5 (VBUS), U5.5 (VCC)
CAN+: J2.2, R3.1, U2.7 (CANH)
CAN-: J2.1, R3.2, U2.6 (CANL)
CAN_RX: U1.1 (D0), U2.4 (RXD)
CAN_TX: U1.2 (D1), U2.1 (TXD)
CH340_D+: U3.4 (I/O2), U5.1 (UD+)
CH340_D-: U3.6 (I/O1), U5.2 (UD-)
D2: J4.5, U1.3 (D2)
D3: J4.6, U1.4 (D3)
D4: J4.7, U1.5 (D4)
D5: J4.8, U1.6 (D5)
D8: J4.4, U1.9 (D8)
D9: J4.3, U1.10 (D9)
D10: J4.2, U1.11 (D10)
ESP_D+: R5.2, U4.4 (I/O2)
ESP_D-: R4.2, U4.6 (I/O1)
ESP_RX: U1.8 (D7), U5.6 (TXD)
ESP_TX: U1.7 (D6), U5.7 (RXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.3, J3.4 (GND), J3.SH (Shield), J4.1, R1.2, R2.2, U1.13 (GND), U1.24 (GND), U1.25 (PAD), U2.2 (VSS), U2.8 (STBY), U3.2 (GND), U4.2 (GND), U5.3 (GND)
unnamed: D1.2 (A), R6.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J1.A6 (D+), J1.B6 (D+), U3.3 (I/O2)
unnamed: J1.A7 (D-), J1.B7 (D-), U3.1 (I/O1)
unnamed: J3.3 (D+), U4.3 (I/O2)
unnamed: J3.2 (D-), U4.1 (I/O1)
unnamed: C4.1, U5.8 (V3)

Board: 4 copper layers, 34.0 x 56.0 mm, 23 parts (0 on the bottom side), 30 nets.

File project/robocon/esp32s3-main-v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C5",0603,5,0.1uF,
C6,CP_Radial_D6.3mm_P2.50mm,1,100uF,
D1,0603,1,LED,
J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,PowerSupply & Programming,
J2,JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,1,CAN,
J3,USB_A_Molex_67643_Horizontal,1,Controller,
J4,JST_XH_B9B-XH-A_1x09_P2.50mm_Vertical,1,GPIO,
"R1, R2",0603,2,5.1kΩ,
R3,0603,1,120Ω,
"R4, R5",0603,2,22Ω,
R6,0603,1,1kΩ,
U1,XIAO-ESP32-S3-SMD,1,XIAO-ESP32-S3-SMD,
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-SN,
"U3, U4",SOT-23-6,2,USBLC6-2SC6,
U5,JEITA_SOIC-8_3.9x4.9mm_P1.27mm,1,CH340N,

## KiCad design project/robocon/xt60-power-hub/xt60-power-hub.kicad_pcb

Parts:
D1: LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: IN; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: OUT1; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J3: OUT2; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J4: OUT3; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J5: OUT5; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
R1: 10kΩ; R_0603_1608Metric

Connections:
+BATT: J1.2, J2.2, J3.2, J4.2, J5.2, R1.1
GND: D1.1 (K), J1.1, J2.1, J3.1, J4.1, J5.1
unnamed: D1.2 (A), R1.2

Board: 2 copper layers, 85.0 x 25.0 mm, 11 parts (0 on the bottom side), 3 nets.

File project/robocon/xt60-power-hub/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
D1,0603,1,LED,
J1,AMASS_XT60PW-M_1x02_P7.20mm_Horizontal,1,IN,
J2,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,OUT1,
J3,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,OUT2,
J4,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,OUT3,
J5,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,1,OUT5,
R1,0603,1,10kΩ,

## Commit log (part)

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2025-07-14 init
2025-07-14 2025/07/14/10:43
2025-07-17 2025/07/17/20:02
2025-07-17 2025/07/17/20:12
2025-07-20 2025/07/20/17:06
2025-07-21 2025/07/21/19:40
2025-07-21 2025/07/21/19:49
2025-07-21 2025/07/21/20:12
2025-07-23 2025/07/23/15:53
2025-07-25 2025/07/25/10:41
2025-07-25 2025/07/25/18:38
2025-07-27 2025/07/27/13:56
2025-08-20 2025/08/20/18:53
2025-09-02 2025/09/03/06:20
2025-09-08 2025/09/08/19:58
2025-09-12 2025/09/12/13:02
2025-09-22 2025/09/22/19:15
2025-09-30 2025/09/30/21:42
2025-10-04 2025/10/04/15:59
2025-10-07 2025/10/07/12:20
2025-10-13 2025/10/14/08:57
2025-10-20 2025/10/20/12:23
2025-10-26 2025/10/26/14:04
2025-10-26 2025/10/26/23:37
2025-10-28 2025/10/28/09:09
2025-11-08 2025/11/08/13:18
2025-11-08 2025/11/09/00:50
2025-12-13 2025/12/13/11:43
2026-01-30 2026/01/30/13:22
2026-03-23 2026/03/23/20:09
2026-03-23 2026/03/23/20:12
2026-03-23 2026/03/23/21:25
2026-03-23 2026/03/23/22:21
2026-03-25 2026/03/25/15:21
2026-04-04 2026/04/04/20:15
2026-04-08 2026/04/08/14:57
2026-04-09 2026/04/09/11:13
2026-04-21 2026/04/22/08:58
2026-04-22 2026/04/22/09:02
2026-04-22 2026/04/22/14:41
2026-04-23 2026/04/23/17:05
2026-05-01 2026/05/01/16:47
2026-06-22 2026/06/22/18:10
2026-06-29 2026/06/29/10:17
